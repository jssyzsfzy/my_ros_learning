Commit message: first

File: exp7_urdf_gazebo/urdf/1_hello.urdf (robot description, URDF)
Before this commit: robot mycar, 1 links, 0 joints
Links:
- link base_link: mass None -> 6
